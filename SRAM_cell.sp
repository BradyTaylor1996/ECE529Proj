Subcircuit: SRAM Cell

* Model
.include 180nm-PTM-BSIM3-Bulk-CMOS-V0-L49-2001.txt
